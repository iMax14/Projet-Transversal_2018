# Keil uVision project Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Slave
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Config_Globale.c Config_PCA.c Config_SPI.c Config_UART0.c Main.c Pointeur_Lumineux.c Servomoteur_Vertical.c Timers.c Transmission_SPI.c Transmission_UART0.c
