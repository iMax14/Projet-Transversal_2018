# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Master
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./Src/: Config_ADC.c Config_Globale.c Config_SPI.c Detect_Obst.c Fonctions_cote_serializer.c Generation_son.c Gpio.c Lien_Structure_commande.c main.c Mesure_courant.c Servomoteur_Horizontal.c Timers.c Transmission_SPI.c UART0_RingBuffer_lib.C UART1.c ultrason.c Encodage_Pointeur_lum.c
